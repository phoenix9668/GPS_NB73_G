# Keil uVision project GPS_NB73_G.uvprojx, settings and files
target GPS_NB73_G (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L010C6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: GPS_NB73_G +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L010x6,USE_FULL_LL_DRIVER,USE_HAL_DRIVER
  c include: ../Inc;                                                                            ../Drivers/STM32L0xx_HAL_Driver/Inc;                                                                            ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;                                                                            ../Drivers/CMSIS/Include;     ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l010x6.s
  group Application/User
    ../Src/: main.c gpio.c lptim.c usart.c spi.c sys.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_gpio.c stm32l0xx_ll_lptim.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_ll_rcc.c stm32l0xx_ll_utils.c stm32l0xx_ll_exti.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_dma.c stm32l0xx_ll_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
software components: CMSIS:CORE 4.3.0
